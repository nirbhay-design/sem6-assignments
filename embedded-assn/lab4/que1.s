	AREA CONDITIONALS , CODE , READONLY
	EXPORT __main
		
__main
	MOV R0,#5000
	MOV R1,#1
	CMP R0,#10
	BLE STORE9N
	CMP R0,#100
	BLE STORE8N
	CMP R0,#1000
	BLE STORE7N
	B STORE6N
	
	
STORE9N
	MOV R2,#9
	MUL R1,R0,R2
	B STOP
	
STORE8N
	MOV R2,#8
	MUL R1,R0,R2
	B STOP
	
STORE7N
	MOV R2,#7
	MUL R1,R0,R2
	B STOP

STORE6N
	MOV R2,#6
	MUL R1,R0,R2
	B STOP
	
STOP B STOP
	END